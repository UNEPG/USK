# Keil uVision project alfasat_trx_fw.uvprojx, settings and files
target unisat_gs_fw_debug (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32L073RZTx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.0.1
  cpu: IROM(0x08000000,0x00030000) IRAM(0x20000000,0x00005000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: gs_fw_debug +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: STM32L073xx, USE_HAL_UART_REGISTER_CALLBACKS=1, USE_STM32L0XX_NUCLEO, USE_HAL_DRIVER, LOW_POWER_DISABLE, GS_BOARD, DEBUG
  c misc: --C99
  c include: ../Drivers\CMSIS\Device\ST\STM32L0xx\Include;..\Middlewares\Third_Party\FreeRTOS\Source\include;..\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS;..\Middlewares\Third_Party\FreeRTOS\Source\portable\RVDS\ARM_CM0;../Drivers\CMSIS\Include;..\Drivers\STM32L0xx_HAL_Driver\Inc\Legacy;../Drivers\STM32L0xx_HAL_Driver\Inc;..\LoRaWAN\App\inc;..\Core\inc;../Middlewares\Third_Party\LoRaWAN\Phy;../Middlewares\Third_Party\LoRaWAN\Utilities;../Drivers\BSP\Components\Common;../Drivers\BSP\Components\sx1276;../Drivers\BSP\sx1276mb1mas;..\unisat_src;..\unisat_lib;..\common_src;..\common_src\board_gs
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x30000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Project/Application
    ../common_src/: main.c debug.c hw_rtc.c hw_spi.c hw_gpio.c stm32l0xx_hw.c stm32l0xx_hal_msp.c
    ../common_src/board_gs/: stm32l0xx_it_gs.c
    ../common_src/board_trx/: stm32l0xx_it_trx.c
  group Drivers/RS485
    ../common_src/: rs485.c board_rs485.c
  group Drivers/Radio
    ../common_src/: ra01.c sx1276.c stm32l0xx_nucleo.c
    ../unisat_src/: board_sx127x.c
  group Drivers/Simcom
    ../common_src/: sim8xx.c
    ../unisat_src/: board_sim8xx.c
  group Project/unisat
    ../unisat_lib/: unisat_utils.c unisat_protocol.c
    ../common_src/: board_eeprom.c board_scheduler.c unisat_processing.c unisat_commands.c board_commands.c
  group Project/Utilities
    ../Middlewares/Third_Party/LoRaWAN/Utilities/: utilities.c timeServer.c low_power_manager.c
  group Project/MDK-ARM
    ../common_src/: startup_stm32l073xx.s
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/ST/STM32L0xx/Source/Templates/: system_stm32l0xx.c
  group Drivers/STM32L0xx_HAL_Driver
    ../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal_spi.c stm32l0xx_hal_uart.c stm32l0xx_hal_adc.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal.c stm32l0xx_hal_cortex.c stm32l0xx_hal_gpio.c stm32l0xx_hal_dma.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_rtc.c stm32l0xx_hal_rtc_ex.c stm32l0xx_hal_tim.c stm32l0xx_hal_tim_ex.c stm32l0xx_hal_adc_ex.c stm32l0xx_hal_uart_ex.c stm32l0xx_hal_i2c.c stm32l0xx_hal_flash.c stm32l0xx_hal_flash_ex.c
  group Middlewares/FreeRTOS
    ../common_src/: freertos.c
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM0/: port.c
target unisat_trx_fw_debug (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32L073RZTx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.0.1
  cpu: as above
  output: gs_fw_debug +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: STM32L073xx, USE_HAL_UART_REGISTER_CALLBACKS=1, USE_STM32L0XX_NUCLEO, USE_HAL_DRIVER, LOW_POWER_DISABLE, DEBUG, TRX_BOARD
  c misc: --C99
  c include: ../Drivers\CMSIS\Device\ST\STM32L0xx\Include;..\Middlewares\Third_Party\FreeRTOS\Source\include;..\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS;..\Middlewares\Third_Party\FreeRTOS\Source\portable\RVDS\ARM_CM0;../Drivers\CMSIS\Include;..\Drivers\STM32L0xx_HAL_Driver\Inc\Legacy;../Drivers\STM32L0xx_HAL_Driver\Inc;..\LoRaWAN\App\inc;..\Core\inc;../Middlewares\Third_Party\LoRaWAN\Phy;../Middlewares\Third_Party\LoRaWAN\Utilities;../Drivers\BSP\Components\Common;../Drivers\BSP\Components\sx1276;../Drivers\BSP\sx1276mb1mas;..\unisat_src;..\unisat_lib;..\common_src;..\common_src\board_trx
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x30000
  memory RVCT9: RAM 0x20000000 size 0x5000
